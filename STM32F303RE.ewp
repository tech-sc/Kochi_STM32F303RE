# IAR project STM32F303RE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32F303RE.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boot
    ./: main.c
  group CubeDrivers
    ./: startup_stm32f303xe.s systemstm32f3xx.c
  group CubeDrivers/HAL_Driver/src
    ./: stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc.c
